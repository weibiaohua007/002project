# Keil uVision project Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: A8507 AMICCOM
  cpu: IRAM(0 - 0xFF) CLOCK(16000000)
  output: Demo +hex
  c flags: Optimize=9
  c include: ..\include;..\BLE Service;..\Lcd
  link misc: NOOVERLAY
  group A51
    ../ASM/: startup.a51
    ../OTA/: FlashChk.a51 INTERRUPT_OFFSET.asm OTA_IAP.asm
  group BLE Library
    ../Library/: A8107_BLE_LIB.LIB
  group OTA
    ../OTA/: OTA.LIB
  group IAP
    ../IAP/: IAP.LIB
  group include
    ../include/: A8107.h define.h IAP.h LibFunction.h mcufunction.h OTA.h security.h
  group Security Setting
    ../Security Setting/: security.c
  group BLE Service
    ../BLE Service/: servicegen.c
  group User Function
    ../source/: mcufunction.c application_check.c interrupt.c main_demo.c
  group User Data
    ../UserData/: IEEE.a51 OTA_Data.a51
  group LCD
    ../Lcd/: LcdFun.c
  group RCADC
    ../RCADC/: RcADC_Table.c A8508_A8126_RCADC_LIB.LIB
