# Keil uVision project Demo_Proprietary.uvproj, settings and files
target Target 1 (MCS-51)
  device: A8107 AMICCOM
  cpu: IRAM(0 - 0xFF) CLOCK(16000000)
  output: Demo_Proprietary +hex
  c flags: Optimize=9
  c include: ..\include;..\BLE Service
  link misc: NOOVERLAY
  group A51
    ../ASM/: startup.a51
    ../OTA/: FlashChk.a51 INTERRUPT_OFFSET.asm OTA_IAP.asm
  group BLE Library
    ../Library/: A8107_BLE_LIB.LIB
  group OTA
    ../OTA/: OTA.LIB
  group IAP
    ../IAP/: IAP.LIB
  group include
    ../include/: A8107.h define.h IAP.h LibFunction.h mcufunction.h OTA.h Proprietary.h security.h
  group Security Setting
    ../Security Setting/: security.c
  group BLE Service
    ../BLE Service/: servicegen.c
  group Proprietary
    ../Proprietary/: Proprietary.LIB
  group User Function
    ../source/: mcufunction.c application_check.c interrupt_24G.c main_24G.c
  group User Data
    ../UserData/: IEEE.a51 OTA_Data.a51
